# Keil uVision project Hung_DTG01.uvprojx, settings and files
target Hung_DTG01 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L071RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Hung_DTG01 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L071xx
  c include: ../Core/Inc;                         ../Drivers/STM32L0xx_HAL_Driver/Inc;                         ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;                         ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                         ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
    ../Drivers/RTT_Debug/: SEGGER_RTT_printf.c SEGGER_RTT_Conf.h SEGGER_RTT.h SEGGER_RTT.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group App
    ../App/: App_Main.c App_Main.h
software components: CMSIS:CORE 5.4.0
